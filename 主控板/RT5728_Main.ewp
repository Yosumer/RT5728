# IAR project RT5728_Main.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: N76E003 N76E003
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Include; User_Include
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: F:\荣泰健康\按摩椅\RT5728\主控板\lnk51ew_N76E003.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    User/: main.c
  group Common
    Common/: Common.c Delay.c IAP.c
  group User
    User/: AutoFunction.c BackPad.c Comm.c FIFO.c Init.c Interrupt.c
  group User_Include
    User_Include/: Function.h Include.h Variable.h
