<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RT5728_Main.ewp</path>
    </project>
    <batchBuild />
</workspace>
